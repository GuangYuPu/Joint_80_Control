# Keil uVision project THDZ_Motor.uvprojx, settings and files
target THDZ_Motor (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F405RG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: THDZ_MOTOR +hex
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__GNUC__,__ICCARM__
  c include: ..\CORE;..\SYSTEM;..\USER;..\FWLIB\inc;..\EtherCAT\Inc;..\EtherCAT\user;..\Hardware;..\SimpleFOC;..\SYSTEM;..\PGY_Code
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/: Protection.c delay.c
    ../SimpleFOC/: FlashRW.c
  group Motor_hardwware
    ../Hardware/: adc.c i2c.c usart0.c usart2.c
  group foc_control
    ../SimpleFOC/: foc_utils.c lowpass_filter.c pid.c lowsideCurrentsense.c BLDCMotor.c CurrentSense.c AS5600.c MotorInit.c tamagawa.c Estimate.c
    ../Hardware/: timer.c ABZ.c OrthPLL.c
  group PGY_Code
    ../PGY_Code/: MCU_Com.c User_Para.c Usermain.c TOP_PLL.c FSM.c
